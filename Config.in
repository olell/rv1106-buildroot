## package/esphosted/Config.in
```kconfig
config BR2_PACKAGE_ESPHOSTED
	bool "esphosted"
	depends on BR2_LINUX_KERNEL
	help
		esphosted
```
